# Keil uVision project project.uvprojx, settings and files
target rt-thread (6190000::V6.19::ARMCLANG)
  device: -AT32F425R8T7 ArteryTek
  pack: ArteryTek.AT32F425_DFP.2.0.7
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __STDC_LIMIT_MACROS, USE_STDPERIPH_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, AT32F425C8T7, RT_USING_ARM_LIBC
  c include: libraries\AT32F425_Firmware_Library\drivers\inc;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\compilers\common\include;rt-thread\components\libc\posix\ipc;libraries\AT32F425_Firmware_Library\cmsis\cm4\device_support;rt-thread\libcpu\arm\common;ports\cherryusb\port\dwc2;board\inc;rt-thread\components\libc\posix\io\stdio;board;applications;ports\DAPLink\DAP;rt-thread\include;ports\DAPLink\SWD_host;rt-thread\libcpu\arm\cortex-m4;libraries\rt_drivers;ports\cherryusb\class\cdc;libraries\rt_drivers\config;ports\cherryusb\core;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\libc\compilers\common\extension;libraries\AT32F425_Firmware_Library\cmsis\cm4\core_support;rt-thread\components\drivers\include;libraries\usbfs_library\inc;.;ports\cherryusb\common;rt-thread\components\drivers\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c cmsis-dap.c
  group CherryUSB
    ports/cherryusb/port/dwc2/: usb_dc_dwc2.c
    ports/cherryusb/core/: usbd_core.c
    ports/cherryusb/class/cdc/: usbd_cdc.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_gcc.S cpuport.c
  group DAPLink
    ports/DAPLink/DAP/: DAP.c SW_DP.c
    ports/DAPLink/SWD_host/: SWD_host.c
  group DeviceDrivers
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
  group Drivers
    board/src/: at32_msp.c board.c
    libraries/AT32F425_Firmware_Library/cmsis/cm4/device_support/startup/mdk/: startup_at32f425.s
    libraries/rt_drivers/: drv_common.c drv_gpio.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c
  group Libraries
    libraries/AT32F425_Firmware_Library/drivers/src/: at32f425_ertc.c at32f425_wwdt.c at32f425_crm.c at32f425_acc.c at32f425_wdt.c at32f425_exint.c at32f425_tmr.c at32f425_pwc.c at32f425_usb.c at32f425_debug.c at32f425_gpio.c at32f425_flash.c at32f425_crc.c at32f425_usart.c at32f425_scfg.c at32f425_misc.c at32f425_adc.c at32f425_can.c at32f425_i2c.c at32f425_spi.c at32f425_dma.c
    libraries/AT32F425_Firmware_Library/cmsis/cm4/device_support/: system_at32f425.c
